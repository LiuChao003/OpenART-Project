# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx5B NXP MIMXRT1052xxx5B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: project.out
  group Applications
    applications/: main.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
  group dlib
    ../../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../libraries/drivers/: drv_gpio.c drv_uart.c
  group Filesystem
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
  group finsh
    ../../../components/finsh/: cmd.c msh.c msh_file.c shell.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/MIMXRT1062/MIMXRT1062/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c
    ../libraries/MIMXRT1062/MIMXRT1062/iar/: startup_MIMXRT1062.s
    ../libraries/MIMXRT1062/MIMXRT1062/: system_MIMXRT1062.c
  group MicroPython
    packages/micropython-latest/py/: argcheck.c asmarm.c asmbase.c asmthumb.c asmx64.c asmx86.c asmxtensa.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitinlinextensa.c emitnarm.c emitnative.c emitnthumb.c emitnx64.c emitnx86.c emitnxtensa.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpy_scheduler.c mpz.c nativeglue.c nlr.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c pystack.c qstr.c reader.c repl.c runtime.c runtime_utils.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c
    packages/micropython-latest/port/native/: easyflash_module.c native_module.c
    packages/micropython-latest/port/: frozen_mpy.c gccollect.c mpgetcharport.c mphalport.c mpputsnport.c mpthreadport.c mpy_main.c
    packages/micropython-latest/lib/utils/: interrupt_char.c mpirq.c printf.c pyexec.c stdout_helpers.c sys_stdio_mphal.c
    packages/micropython-latest/port/modules/machine/: machine_adc.c machine_hw_i2c.c machine_hw_spi.c machine_lcd.c machine_pin.c machine_pwm.c machine_rtc.c machine_timer.c machine_uart.c machine_wdt.c modmachine.c
    packages/micropython-latest/extmod/: machine_i2c.c machine_mem.c machine_pinbase.c machine_pulse.c machine_signal.c machine_spi.c modbtree.c modframebuf.c modonewire.c modubinascii.c moducryptolib.c moductypes.c moduhashlib.c moduheapq.c modujson.c modurandom.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c modutimeq.c moduwebsocket.c moduzlib.c modwebrepl.c modwebsocket.c uos_dupterm.c utime_mphal.c vfs.c vfs_fat.c vfs_fat_diskio.c vfs_fat_file.c vfs_posix.c vfs_posix_file.c vfs_reader.c virtpin.c
    packages/micropython-latest/port/modules/: modffi.c modfile.c modnetwork.c modnetwork_wlan.c modpyb.c modrtthread.c moduos.c moduos_file.c modusocket.c modutils.c modutime.c
    packages/micropython-latest/lib/netutils/: netutils.c
    packages/micropython-latest/lib/mp-readline/: readline.c
    packages/micropython-latest/drivers/bus/: softqspi.c softspi.c
    packages/micropython-latest/lib/timeutils/: timeutils.c
  group netdev
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal_socket/src/: sal_socket.c
  group xip
    xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
